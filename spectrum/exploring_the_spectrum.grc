options:
  parameters:
    generate_options: qt_gui
    id: exploring_the_spectrum
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centre_freq
  id: variable
  parameters:
    value: '800000000'
  states: {}
- name: rf_gain_db
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: centre_freq
    gain0: rf_gain_db
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: centre_freq
    fftsize: '1024'
    name: '"Spectrum & Waterfall"'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [dc_blocker_xx_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
